# Keil uVision project stm32f1_modbusMaster.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_modbusMaster +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DEBUG_MSG
  c misc: --gnu
  c include: ..\common;..\dirver;..\module;..\user;..\util;..\lib\modbus\include;..\lib\modbus\include\rtu;..\lib\modbus\include\ascii;..\lib\modbus\port;..\module\memmange
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group driver
    ../dirver/: logdrv.c systick.c
  group user
    ../user/: main.c stm32f10x_it.c
  group module
    ../module/memmange/: heap_4.c
    ../module/: log.c msglink.c
  group mastermodbus
    ../lib/modbus/src/func/: mbmfunc.c mbmfuncbits.c mbmfuncother.c mbmfuncregs.c
    ../lib/modbus/src/ascii/: mbmascii.c
    ../lib/modbus/src/rtu/: mbmrtu.c
    ../lib/modbus/src/: mbmbuf.c mbm.c
  group modbuscommon
    ../lib/modbus/src/func/: mbutils.c
  group modbusport
    ../lib/modbus/port/: mbmem.c porttimer.c portserial.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
